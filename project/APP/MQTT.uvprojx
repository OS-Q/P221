# Keil uVision project MQTT.uvprojx, settings and files
target ALI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32EC20 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYS\delay;..\SYS\sys;..\SYS\usart;..\APP;..\LIB\inc;..\CM3;..\BSP\LED;..\BSP\KEY;..\BSP\OLED;..\BSP\USART2;..\SIM800C;..\BSP\USART3;..\LCD5110;..\HTTP;..\BSP\EC20;..\BSP\MODBUS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c timer.c
  group CM3
    ../CM3/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group SYS
    ../SYS/delay/: delay.c
    ../SYS/sys/: sys.c
    ../SYS/usart/: usart.c
  group BSP
    ../BSP/KEY/: key.c
    ../BSP/LED/: led.c
    ../BSP/USART2/: usart2.c
    ../BSP/USART3/: usart3.c
    ../BSP/MODBUS/: MODBUS.C
    ../BSP/EC20/: EC20.c
